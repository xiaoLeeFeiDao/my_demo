# IAR project test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CortexM7MPS2FVP Cortex-M7 MPS2 FVP
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCIncludePath2: D:\code\learn_platform; D:\code\learn_platform\cpp_learn; D:\code\learn_platform\cpp_learn\include; D:\code\learn_platform\demo; D:\code\learn_platform\demo\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: D:\code\learn_platform\cpp_learn\include
  OBJCOPY.OOCOutputFile: test.srec
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 0
  group (top)
    ../: main.cpp
  group cpp_learn
    ../cpp_learn/: 01_helloworld.cpp 02_scope_resolution.cpp 03_namespace.cpp 04_using_declear_using_compile_order.cpp 05_c++_enhance_c_at_c++.cpp 05_c++_enhance_c_at_c.c 06_c++_enhance_c_at_const.c 07_const_default_out_linker_at_c.c 07_test4c.c 08_const_default_inner_linker_at_c++.cpp 08_test4cpp.cpp 09_const_mem_malloc.cpp 10_reference_base_using.cpp 11_reference_args_pass_method.cpp 12_pointer_reference.cpp 13_const_value_reference.cpp 14_inner_func.cpp 15_func_default_arg_and_place_holder.cpp 16_func_overload.cpp 17_encapsulation.cpp 18_construct_and_disstruct.cpp 19_construct_called_ruler.cpp 20_depth_and_shallow_copy.cpp 21_init_list.cpp 22_clash_obj_as_class_memb.cpp 23_new_operator.cpp 24_static_memb_attr.cpp 25_single_mode.cpp 26_printer_single_mode.cpp 27_introduction_to_object_models.cpp 28_this_pointer.cpp 29_null_pointer_visit_memb_func.cpp 30_const_func_and_const_obj.cpp 31_friend_func.cpp 32_overloading_plus_operator.cpp 33_overloading_increment_operator.cpp 34_overloading_pointer_operator.cpp 35_overloading_assignment_operator.cpp 36_overloading_relational_operators.cpp 37_function_call_operator_overload.cpp 38_inheritance.cpp 39_inheritance_object_model.cpp 40_inheritance_constructors_and_destructors.cpp 41_inheritance_handling_same_name_members.cpp 42_inheritance_static_members_handling.cpp 43_multiple_inheritance_concepts_and_issues.cpp 44_diamond_inheritance_and_virtual_inheritance.cpp 45_virtual_inheritance_internal_mechanism.cpp 46_func_template_and_normal_func_diff.cpp 47_static_binding_and_dynamic_binding.cpp 48_class_template.cpp cpp_learn.cpp cpp_learn_inner.h eg1_design_a_class_to_calculate_circle_perimeter.cpp eg2_design_a_student_class.cpp eg3_property_and_method_access.cpp eg4_set_cube_class.cpp eg5_judgeRelationCirclePoint.cpp eg6_package_array_class.cpp eg6_package_array_class.h eg7_package_string_class.cpp eg7_package_string_class.h game1.cpp game1.h game2.cpp game2.h
  group cpp_learn/include
    ../cpp_learn/include/: cpp_learn.h
  group demo
    ../demo/: demo.cpp demo_inner.h demo_test01.cpp demo_test02.cpp demo_test03.cpp
  group demo/include
    ../demo/include/: demo.h
